# Keil uVision project F1-Architecture.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F1-Architecture +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\source\system\inc;..\..\source\priph_cfg\inc;..\..\source\system\inc;..\..\source\app\inc;..\..\FreeRTOS\inc;..\..\source\APP\inc;..\..\source\APP_API\inc;..\..\source\TASK\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h core_cm3.h system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PERIPH_CFG
    ../../source/priph_cfg/src/: stm32f10x_adc_config.c stm32f10x_can_config.c stm32f10x_dac_config.c stm32f10x_dma_config.c stm32f10x_exti_config.c stm32f10x_flash_config.c stm32f10x_gpio_config.c stm32f10x_i2c_config.c stm32f10x_iwdg_config.c stm32f10x_spi_config.c stm32f10x_tim_config.c stm32f10x_usart_config.c
  group FreeRTOS
    ../../FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group APP_API
    ../../source/APP_API/src/: api_adc.c api_can.c api_exti.c api_flash.c api_i2c.c api_iwdg.c api_spi.c api_tim.c api_usart.c
  group APP
    ../../source/APP/src/: app_hal_init.c app_heart_led.c app_magnetic_encoder.c
  group TASK
    ../../source/TASK/src/: task_can_receive.c task_error_process.c task_heart_led.c task_motor_control.c task_test.c
  group SYSTEM
    ../../source/system/src/: project_main.c
    ../../source/system/inc/: can_macro.h common.h
